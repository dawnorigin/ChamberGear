# IAR project Play_Button.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\Source\FreeRTOSv8.0.1\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\Source\FreeRTOSv8.0.1\FreeRTOS\Source\include; ..\..\..\Source\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Source\CMSIS\Include; ..\..\..\Source\CMSIS\Core\CM3; ..\..\..\Source\Application\Play_Button
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Source\Application\Play_Button
  OBJCOPY.OOCOutputFile: Play_Button.srec
  ILINK.IlinkOutputFile: Play_Button.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: readme.txt
  group Application
    ../../../Source/Application/Play_Button/: ApplicationConfig.h ApplicationTasks.c FreeRTOSConfig.h main.c player.c SerialIO.c stm32f10x_conf.h stm32f10x_it.c
  group CMSIS
    ../../../Source/CMSIS/Core/CM3/startup/: startup_stm32f10x_md.s
    ../../../Source/CMSIS/Core/CM3/: system_stm32f10x.c
  group FreeRTOS
    ../../../Source/FreeRTOSv8.0.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Source/FreeRTOSv8.0.1/FreeRTOS/Source/: list.c queue.c tasks.c
  group FreeRTOS/Portable
    ../../../Source/FreeRTOSv8.0.1/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group StdPeriph_Lib
    ../../../Source/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
